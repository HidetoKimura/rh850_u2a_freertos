# IAR project Y-ASK-RH850U2A16.ewp, settings and files
configuration Debug (RH850, debug)
  General.GDeviceSelect: R7F702300A RH850 - R7F702300A
  General.GHeapSize: 0x1000
  ICCRH850.IccLang: 0
  ICCRH850.CCOptLevel: 1
  ICCRH850.CCOptStrategy: 0
  ICCRH850.CCDiagSuppress: Pa089
  ICCRH850.CCIncludePath2: $PROJ_DIR$; ..\..\..\source\; ..\..\..\source\inc\; ..\..\..\source\drivers\U2A16_SmartConfigurator\SmartConfigurator\; ..\..\..\source\drivers\U2A16_SmartConfigurator\SmartConfigurator\r_pincfg; ..\..\..\source\drivers\U2A16_SmartConfigurator\SmartConfigurator\general; ..\..\..\source\drivers\U2A16_SmartConfigurator\SmartConfigurator\ADCJ1; ..\..\..\source\drivers\U2A16_SmartConfigurator\SmartConfigurator\ADCJ2; ..\..\..\source\drivers\U2A16_SmartConfigurator\SmartConfigurator\INTC; ..\..\..\source\drivers\U2A16_SmartConfigurator\SmartConfigurator\MSPI30; ..\..\..\source\drivers\U2A16_SmartConfigurator\SmartConfigurator\OSTM0; ..\..\..\source\drivers\U2A16_SmartConfigurator\SmartConfigurator\PORT; ..\..\..\source\drivers\U2A16_SmartConfigurator\SmartConfigurator\RIIC0; ..\..\..\source\drivers\U2A16_SmartConfigurator\SmartConfigurator\RLIN39; ..\..\..\source\drivers\U2A16_SmartConfigurator\SmartConfigurator\STBC; ..\..\..\source\drivers\U2A16_SmartConfigurator\SmartConfigurator\TAUD0; ..\..\..\source\drivers\U2A16_SmartConfigurator\SmartConfigurator\TAUD2; ..\..\..\source\thirdparty\lwip; ..\..\..\source\thirdparty\lwip\include; ..\..\..\source\drivers\U2A16_SmartConfigurator
  OBJCOPY.OOCOutputFile: Y-ASK-RH850U2A16.srec
  ILINK.IlinkOutputFile: Y-ASK-RH850U2A16.out
  ILINK.IlinkIcfFile: lnkr7f702300a.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start4_g4
configuration Release (RH850)
  as the first configuration, except:
  General.GDeviceSelect: UnspecifiedG3M RH850 G3M - Unspecified
  ICCRH850.CCOptLevel: 3
  ICCRH850.CCDefines: NDEBUG
  group (top)
    ./: cstartup4_g4.s
  group pe0
    ../../../source/: low_level_init_pe0.c main_pe0.c
  group pe0/apps/sdCommands
    ../../../source/apps/sdCommands/: r_sdCommands.c
  group pe0/apps/standby
    ../../../source/apps/standby/: r_standby.c r_standby.h
  group pe0/apps/systemTest
    ../../../source/apps/systemTest/: r_systemTest.c
  group pe0/apps/ui
    ../../../source/apps/ui/: r_ui.c r_ui.h
  group pe0/drivers/enc
    ../../../source/drivers/enc/: r_enc.c r_enc.h
  group pe0/drivers/gpio
    ../../../source/drivers/gpio/: r_gpio_helper.h
  group pe0/drivers/mmca
    ../../../source/drivers/mmca/: r_MMCA.c r_MMCA.h
  group pe0/drivers/pwmd
    ../../../source/drivers/pwmd/: r_pwmd.c r_pwmd.h
  group pe0/drivers/rlin
    ../../../source/drivers/rlin/: r_rlin.c r_rlin.h
  group pe0/drivers/rscanfd
    ../../../source/drivers/rscanfd/: r_rscfd.c r_rscfd.h r_rscfd_cfg.h r_rscfd_dev.h r_types.h
  group pe0/drivers/SmartConfigurator/ADC
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/ADCJ1/: ADCJ1.c ADCJ1.h ADCJ1_user.c
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/ADCJ2/: ADCJ2.c ADCJ2.h ADCJ2_user.c
  group pe0/drivers/SmartConfigurator/general
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/general/: r_cg_ad.h r_cg_ad_common.c r_cg_ad_common.h r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_intc.h r_cg_intc_PE0.c r_cg_intvector_PE0.c r_cg_macrodriver.h r_cg_mspi.h r_cg_mspi_common.c r_cg_mspi_common.h r_cg_mspi_common_user.c r_cg_ostm.h r_cg_port.h r_cg_riic.h r_cg_stbc.h r_cg_taud.h r_cg_tauj.h r_cg_uart.h r_cg_userdefine.h r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group pe0/drivers/SmartConfigurator/INTC
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/INTC/: INTC.c INTC.h INTC_user.c
  group pe0/drivers/SmartConfigurator/MSPI
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/MSPI30/: MSPI30.c MSPI30.h MSPI30_user.c
  group pe0/drivers/SmartConfigurator/OSTM
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/OSTM0/: OSTM0.c OSTM0.h OSTM0_user.c
  group pe0/drivers/SmartConfigurator/PORT
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/PORT/: PORT.c PORT.h PORT_user.c
  group pe0/drivers/SmartConfigurator/r_pincfg
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/r_pincfg/: Pin.c Pin.h
  group pe0/drivers/SmartConfigurator/RIIC
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/RIIC0/: RIIC0.c RIIC0.h RIIC0_user.c
  group pe0/drivers/SmartConfigurator/RLIN
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/RLIN39/: RLIN39.c RLIN39.h RLIN39_user.c
  group pe0/drivers/SmartConfigurator/STBC
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/STBC/: STBC.c STBC.h STBC_user.c
  group pe0/drivers/SmartConfigurator/TAU
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/TAUD0/: TAUD0.c TAUD0.h TAUD0_user.c
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/TAUD2/: TAUD2.c TAUD2.h TAUD2_user.c
  group pe0/drivers/stbc_iohold
    ../../../source/drivers/stbc_iohold/: r_stbc_iohold.c r_stbc_iohold.h
  group pe0/modules/canfd
    ../../../source/modules/canfd/: r_canfd.c r_canfd.h
  group pe0/modules/display
    ../../../source/modules/display/: font12x16.h font5x7.h r_display.c r_display.h r_image.c r_image.h r_menu.c r_menu.h
  group pe0/modules/leds
    ../../../source/modules/leds/: r_led.c r_led.h
  group pe0/modules/lin
    ../../../source/modules/lin/: r_lin.c r_lin.h
  group pe0/modules/sdcard
    ../../../source/modules/sdcard/: r_SDIO.c r_SDIO.h
  group pe0/modules/uart
    ../../../source/modules/uart/: r_uart.c r_uart.h
  group pe0/modules/userInput
    ../../../source/modules/userInput/: r_userInput.c r_userInput.h
  group pe0/thirdparty/fatfs
    ../../../source/thirdparty/fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c LICENSE.txt
  group pe0/thirdparty/shell
    ../../../source/thirdparty/shell/: shell.c shell.h shell_config.h
  group pe0/thirdparty/shell/lib/a2i
    ../../../source/thirdparty/shell/lib/a2i/: a2i.c a2i.h
  group pe0/thirdparty/shell/lib/printf
    ../../../source/thirdparty/shell/lib/printf/: printf.c printf.h
  group pe1
    ../../../source/: main_pe1.c
  group pe1/driver/etnb0
    ../../../source/drivers/etnb0/: map_eth.h r_at_ram_if.c r_at_ram_if.h r_avb_api.h r_avb_main.c r_avb_main.h r_avb_regs.h r_avb_sys.h r_config_avb.h r_dev_api.h r_ethernet_phy.c r_ethernet_phy.h r_typedefs.h
  group pe1/driver/SmartConfigurator/general
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/general/: r_cg_intc_PE1.c r_cg_intvector_PE1.c
  group pe1/modules/eth
    ../../../source/modules/eth/: r_eth.c r_eth.h
  group pe1/thirdparty/lwip
    ../../../source/thirdparty/lwip/: ethernetif.c lwipopts.h
  group pe1/thirdparty/lwip/api
    ../../../source/thirdparty/lwip/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group pe1/thirdparty/lwip/apps/http
    ../../../source/thirdparty/lwip/apps/http/: httpd.c r_cgi.c r_ssi.c
  group pe1/thirdparty/lwip/apps/http/website
    ../../../source/thirdparty/lwip/apps/http/website/: fs.c
  group pe1/thirdparty/lwip/apps/lwiperf
    ../../../source/thirdparty/lwip/apps/lwiperf/: lwiperf.c
  group pe1/thirdparty/lwip/arch
    ../../../source/thirdparty/lwip/arch/: cc.h perf.h sys_arch.c sys_arch.h
  group pe1/thirdparty/lwip/core
    ../../../source/thirdparty/lwip/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group pe1/thirdparty/lwip/core/ipv4
    ../../../source/thirdparty/lwip/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group pe1/thirdparty/lwip/core/ipv6
    ../../../source/thirdparty/lwip/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group pe1/thirdparty/lwip/netif
    ../../../source/thirdparty/lwip/netif/: ethernet.c
  group pe2
    ../../../source/: main_pe2.c
  group pe2/driver/SmartConfigurator/general
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/general/: r_cg_intc_PE2.c r_cg_intvector_PE2.c
  group pe3
    ../../../source/: main_pe3.c
  group pe3/driver/SmartConfigurator/general
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/general/: r_cg_intc_PE3.c r_cg_intvector_PE3.c
  group shared
    ../../../source/: shared.c shared.h
  group shared/driver/ltsc
    ../../../source/drivers/ltsc/: r_ltsc.c r_ltsc.h
  group shared/driver/SmartConfigurator/general
    ../../../source/drivers/U2A16_SmartConfigurator/SmartConfigurator/general/: r_smc_intprg.c
  group shared/modules/systimer
    ../../../source/modules/systimer/: r_systimer.c r_systimer.h
