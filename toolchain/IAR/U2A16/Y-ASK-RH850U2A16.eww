<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Y-ASK-RH850U2A16.ewp</path>
    </project>
    <batchBuild />
</workspace>
